
SUMMARY = "A simple user space application for opening the driver file"
DESCRIPTION = "${SUMMARY}"


# Sources
SRC_URI = "git://github.com/Benali-Samar/MCP_apps.git;protocol=https;branch=main"
SRCREV = "1eff717044167a908c483233abe318069d71e733"


require mcpapp.inc
