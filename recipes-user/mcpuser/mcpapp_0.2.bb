
SUMMARY = "A QT graphical app for the driver's temperature"
DESCRIPTION = "${SUMMARY}"

# No license specified
LICENSE = "CLOSED"

# Sources ==> to specify
#SRC_URI = "git://github.com/Benali-Samar/MCP_apps.git;protocol=https;branch=main"
#SRCREV = "6c3e0dc8cdfb34839684c7b938de8c6d06d83555"

# Unpacking
#S = "${WORKDIR}/git"

# Compiling

# Installing

# Packaging




